# Keil uVision project robc.uvproj, settings and files
target COM-OBC (ARM-ADS)
  device: STM32F100R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: robc +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD_VL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group System
    ./: system_stm32f10x.c startup_stm32f10x_md_vl.s
  group Tests
    ./: test_fram.c test_bus.c test_morse.c test_fm.c test_packet.c test_i2cadc.c test_adc.c demo_A.c test_fmrx.c test_hdlcrx.c test_hdlctx.c test_fec_rx.c test_fec_tx.c test_bgate.c test_bkp.c test_hdlctrx.c test_i2camp.c
  group PilsenCUBE
    ./: i2c.c robc_hal.c ax5043.c morse.c ax25.c pils_fram.c pils_main.c pils_bus.c pils_adc.c pils_bkp.c
